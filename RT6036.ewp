# IAR project RT6036.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG280F128
  ICCARM.CCIncludePath2: ; emlib\inc\; Device\EnergyMicro\EFM32LG\Include; CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT6036_Main_US003_V1.01_20170621.bin
  ILINK.IlinkOutputFile: 6036.out
  ILINK.IlinkIcfFile: RT7710.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Device/EnergyMicro/EFM32LG/Source/IAR/: startup_efm32lg.s
    Device/EnergyMicro/EFM32LG/Source/: system_efm32lg.c
  group emlib
    emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_letimer.c em_leuart.c em_msc.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Local
    ./: main.c system.c
  group Peripheral
    ./: adc_single.c BackPad.c BlueTooth.c DAC_RT8600.c DMAUart.c FlexPad.c Hot_Roller.c IndicateLED.c Input.c KneadMotor.c KnockMotor.c LED_RGB.c LegMotor.c memory.c Mp3Ctrl.c Power.c SlideMotor.c Valve.c WaistHot.c WalkMotor.c
  group Software
    ./: Data_Cul.c MassageStatus.c Timer.c
